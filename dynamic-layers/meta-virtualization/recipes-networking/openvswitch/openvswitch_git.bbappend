export ovs_cv__mavx512f_mavx512vpopcntdq="no"
export ovs_cv_binutils_avx512_good="no"
