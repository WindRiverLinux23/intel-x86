require linux-yocto-intel-x86.inc

LINUX_VERSION:intel-x86 = "6.0+"
KBRANCH:intel-x86  = "v6.0/standard/x86"
