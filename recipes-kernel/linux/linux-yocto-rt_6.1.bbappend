require linux-yocto-intel-x86.inc

KBRANCH:intel-x86  = "v6.1/standard/preempt-rt/x86"
