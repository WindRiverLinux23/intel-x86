require linux-yocto-intel-x86.inc

KBRANCH:intel-x86  = "v6.1/standard/x86"

LINUX_VERSION:intel-x86 ?= "6.1.x"
