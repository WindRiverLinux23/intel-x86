require linux-yocto-intel-x86.inc

KBRANCH:intel-x86  = "v5.10/standard/preempt-rt/x86"

LINUX_VERSION:intel-x86 ?= "5.10.x"
