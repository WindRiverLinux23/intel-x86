require linux-yocto-intel-x86.inc

KBRANCH:intel-x86  = "v5.15/standard/preempt-rt/x86"

LINUX_VERSION:intel-x86 ?= "5.15.x"
