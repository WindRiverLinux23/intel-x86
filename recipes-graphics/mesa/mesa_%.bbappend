EXTRA_OEMESON:append:intel-x86-64 = " -Dprefer-iris=true"
GALLIUMDRIVERS:append:intel-x86-64 = ",iris"
